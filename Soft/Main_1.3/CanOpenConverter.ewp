# IAR project CanOpenConverter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F437VI ST STM32F437VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427_437xx; NDEBUG; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: src; ..\Include\; ..\Include\CMSIS\; ..\Include\CMSIS\Include; ..\Include\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Include\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Include\Sun_CAN
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CanOpenConv.hex
  ILINK.IlinkOutputFile: CanOpenConvt.out
  ILINK.IlinkIcfFile: src\config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: main.c stm32f4xx_it.c system_stm32f4xx.c TODO & Some Notes.c
    ../Include/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../Include/: ringbuffer.c
    ../Include/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427_437xx.s
    ../Include/Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
