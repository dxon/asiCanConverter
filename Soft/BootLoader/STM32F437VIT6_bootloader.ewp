# IAR project STM32F437VIT6_bootloader.ewp, settings and files
configuration Release_STM32F437VIT6 (ARM)
  General.OGChipSelectEditMenu: STM32F437VI ST STM32F437VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; STM32F437VIT6; STM32F427_437xx
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Include\Sun_CAN\; ..\Include\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot_rct6.hex
  ILINK.IlinkOutputFile: BootLoader_STM32F.out
  ILINK.IlinkIcfFile: config\stm32f437vit6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Bootloader.c startupBoot_md.s stm32f4xx_it.c system_stm32f4xx.c
    ../Include/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c
